Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:On]
File name: SCI_MANE.ifc
Time: 2021-06-01T16:48:58
Author: PORTCM01\professeur
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures Educational 2019, IFC Export Version: 4.0.0.0 Mar 7 2019

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: D22 (10)
In: Undefined
Description: D22; Material: STEEL/S235JR
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 24.5 m2; Surface nette: 0 m2; Hauteur: 22 mm; Largeur: 22 mm; Longueur: 526.9 mm; sets with these values: 2
Tekla Commun - Repère de pièce: B1; Repère d'assemblage: B1; Phase: 1; Profil: D22; Nom: BARRE; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: B1
BaseQuantities - Length: 526.936 mm; OuterSurfaceArea: 0.0372007 m2; NetVolume: 0.000193467 m3; NetWeight: 1.51872 kg

# IfcBeam: HEA100 (3)
In: Undefined
Description: HEA100; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: HEA100; Nom: BAILLONNETTE; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 33.6 m2; Hauteur: 96 mm; Largeur: 100 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
BAILLONNETTE | 97 | P26 | 11 | 0.4 | 658 | 657.982 | 0.369128 | 0.00131289 | 10.3062
BAILLONNETTE | 96 | P25 | 13 | 0.5 | 782.7 | 782.683 | 0.439085 | 0.00156229 | 12.264
BAILLONNETTE | 95 | P24 | 13 | 0.5 | 779 | 778.993 | 0.437015 | 0.00155491 | 12.206

# IfcBeam: IPE120 (34)
In: Undefined
Description: IPE120; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: IPE120; Nom: PANNE; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface par tonne: 45.8 m2; Hauteur: 120 mm; Largeur: 64 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x PANNE | PA6 | PA6 | 122.6 | 0.8 | 5.8 | 11830 | 5.61925 | 0.0151301 | 118.771
2 x PANNE | PA4 | PA4 | 57 | 0.4 | 2.7 | 5505 | 2.61487 | 0.00704067 | 55.2693
6 x PANNE | PA4 | PA4 | 57 | 0 | 2.7 | 5505 | 2.61487 | 0.00704067 | 55.2693
2 x PANNE | PA7 | PA7 | 112.3 | 0.7 | 5.3 | 10835 | 5.14662 | 0.0138575 | 108.782
8 x PANNE | PA7 | PA7 | 112.3 | 0 | 5.3 | 10835 | 5.14662 | 0.0138575 | 108.782
6 x PANNE | PA6 | PA6 | 122.6 | 0 | 5.8 | 11830 | 5.61925 | 0.0151301 | 118.771
2 x PANNE | 160 | PA1 | 57 | 0 | 2.7 | 5505 | 2.61487 | 0.00704067 | 55.2693
2 x PANNE | PA3 | PA3 | 40.1 | 0 | 1.9 | 3866 | 1.83635 | 0.00494446 | 38.814
2 x PANNE | 162 | PA2 | 122.6 | 0 | 5.8 | 11830 | 5.61925 | 0.0151301 | 118.771
2 x PANNE | PA5 | PA5 | 105.6 | 0 | 5 | 10191 | 4.84072 | 0.0130339 | 102.316

# IfcBeam: IPE270 (18)
In: Undefined
Description: IPE270; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: IPE270; Nom: POUTRE; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface par tonne: 28.9 m2; Hauteur: 270 mm; Largeur: 135 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POUTRE | 79 | PT8 | 95.5 | 0.4 | 2.8 | 2649.3 | 2649.35 | 2.75797 | 0.0116607 | 91.5368
7 x POUTRE | PT12 | PT12 | 220.3 | 0.8 | 6.5 | 6113.4 | 6113.4 | 6.36405 | 0.0269073 | 211.222
POUTRE | 77 | PT10 | 216.8 | 0.8 | 6.4 | 6018 | 6018 | 6.26474 | 0.0264874 | 207.926
POUTRE | 76 | PT9 | 218.8 | 0.8 | 6.5 | 6071.7 | 6071.7 | 6.32064 | 0.0267237 | 209.781
POUTRE | 75 | PT6 | 134.6 | 0.5 | 4 | 3734.7 | 3734.7 | 3.88782 | 0.0164378 | 129.036
POUTRE | 74 | PT7 | 108.7 | 0.4 | 3.2 | 3017.5 | 3017.5 | 3.14122 | 0.0132811 | 104.257
POUTRE | 69 | PT2 | 361.9 | 1.4 | 10.7 | 10045 | 10045 | 10.4568 | 0.0442117 | 347.062
POUTRE | 73 | PT5 | 150.2 | 0.6 | 4.5 | 4167.5 | 4167.5 | 4.33837 | 0.0183427 | 143.99
POUTRE | 72 | PT4 | 148 | 0.6 | 4.4 | 4107.3 | 4107.35 | 4.27575 | 0.0180779 | 141.912
POUTRE | 71 | PT3 | 151.4 | 0.6 | 4.5 | 4202 | 4202 | 4.37428 | 0.0184945 | 145.182
POUTRE | 70 | PT13 | 220.2 | 0.8 | 6.5 | 6110.6 | 6110.6 | 6.36113 | 0.0268949 | 211.125
POUTRE | PT11 | PT11 | 220.2 | 0.8 | 6.5 | 6110.6 | 6110.6 | 6.36113 | 0.0268949 | 211.125

# IfcBeam: IPE360 (10)
In: Undefined
Description: IPE360; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: IPE360; Nom: POUTRE; sets with these values: 2
Tekla Quantités - Poids: 500.2 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Surface par tonne: 23.7 m2; Surface nette: 12.1 m2; Hauteur: 360 mm; Largeur: 170 mm; Longueur: 8765.2 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 8765.21 mm; OuterSurfaceArea: 11.8593 m2; NetVolume: 0.0612334 m3; NetWeight: 480.682 kg
Name | Repère de pièce = Reference | Repère d'assemblage
POUTRE | 108 | A11
POUTRE | 108 | A10
POUTRE | 108 | A7
POUTRE | 108 | A6
2 x POUTRE | 108 | A5
POUTRE | 108 | A9
POUTRE | 108 | A8
POUTRE | 107 | A4
POUTRE | 106 | A3

# IfcBeam: L40*4, CAE DP
In: Undefined
Description: L40*4; Material: STEEL/S235JR
Tekla Quantités - Poids: 17.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.1 m2; Surface nette: 1.1 m2; Hauteur: 40 mm; Largeur: 40 mm; Longueur: 7100 mm; sets with these values: 2
Tekla Commun - Repère de pièce: A12; Repère d'assemblage: A12; Phase: 1; Profil: L40*4; Nom: CAE DP; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: A12
BaseQuantities - Length: 7099.99 mm; OuterSurfaceArea: 1.1005 m2; NetVolume: 0.0021584 m3; NetWeight: 16.9434 kg

# IfcBeam: L70*7 (2)
In: Undefined
Description: L70*7; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLATS3; Repère d'assemblage: PLATS3; Phase: 1; Profil: L70*7; Nom: PLATS; sets with these values: 2
Tekla Quantités - Poids: 7.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 36.9 m2; Surface nette: 0.3 m2; Hauteur: 70 mm; Largeur: 70 mm; Longueur: 1010 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: PLATS3
BaseQuantities - Length: 1010 mm; OuterSurfaceArea: 0.27472 m2; NetVolume: 0.00094031 m3; NetWeight: 7.38143 kg

# IfcBeam: TUBE-21.3*2 (2)
In: Undefined
Description: TUBE-21.3*2; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLATS4; Repère d'assemblage: PLATS4; Phase: 1; Profil: TUBE-21.3*2; Nom: PLATS; sets with these values: 2
Tekla Quantités - Poids: 9.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 69.5 m2; Surface nette: 0.7 m2; Hauteur: 21.3 mm; Largeur: 21.3 mm; Longueur: 10070 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: PLATS4
BaseQuantities - Length: 10070 mm; OuterSurfaceArea: 0.6663 m2; NetVolume: 0.00116611 m3; NetWeight: 9.15393 kg

# IfcBeam: TUBE-52*3, PLATS
In: Undefined
Description: TUBE-52*3; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLATS2; Repère d'assemblage: PLATS2; Phase: 1; Profil: TUBE-52*3; Nom: PLATS; sets with these values: 2
Tekla Quantités - Poids: 36.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.8 m2; Surface nette: 1.6 m2; Hauteur: 52 mm; Largeur: 52 mm; Longueur: 10070 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: PLATS2
BaseQuantities - Length: 10070 mm; OuterSurfaceArea: 1.63499 m2; NetVolume: 0.00453186 m3; NetWeight: 35.5751 kg

# IfcBeam: TUBE-C-100*100*3 (10)
In: Undefined
Description: TUBE-C-100*100*3; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: TUBE-C-100*100*3; Nom: LISSE; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface par tonne: 43.6 m2; Hauteur: 100 mm; Largeur: 100 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x LISSE | 128 | L18 | 96.7 | 1.1 | 4.3 | 10805 | 10805 | 4.21395 | 0.0124955 | 98.0899
LISSE | 130 | L20 | 88.2 | 1 | 3.9 | 9852.5 | 9852.5 | 3.84247 | 0.0113868 | 89.3865
2 x LISSE | 129 | L19 | 82.6 | 0 | 3.7 | 9228.6 | 9228.59 | 3.59915 | 0.0107038 | 84.025
2 x LISSE | 125 | L15 | 57.7 | 0.6 | 2.6 | 6442.5 | 6442.5 | 2.51258 | 0.00749907 | 58.8677
LISSE | 127 | L17 | 75.1 | 0.8 | 3.3 | 8392.5 | 8392.5 | 3.27307 | 0.00968738 | 76.0459
2 x LISSE | 126 | L16 | 96.9 | 1.1 | 4.3 | 10822.5 | 10822.5 | 4.22077 | 0.0125159 | 98.2497

# IfcBeam: TUBE-C-40*40*3 (9)
In: Undefined
Description: TUBE-C-40*40*3; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: L26; Repère d'assemblage: L26; Phase: 1; Profil: TUBE-C-40*40*3; Nom: LINTEAU; sets with these values: 2
Tekla Quantités - Poids: 5.9 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 45.1 m2; Surface nette: 0.3 m2; Hauteur: 40 mm; Largeur: 40 mm; Longueur: 1800 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: L26
BaseQuantities - Length: 1800 mm; OuterSurfaceArea: 0.2682 m2; NetVolume: 0.0007992 m3; NetWeight: 6.27372 kg

# IfcBeam: TUBE-C-80*80*3 (20)
In: Undefined
Description: TUBE-C-80*80*3; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: TUBE-C-80*80*3; Nom: STAB; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface par tonne: 43.7 m2; Hauteur: 80 mm; Largeur: 80 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x STAB | ST11 | ST11 | 35.7 | 0 | 1.6 | 5053 | 5053 | 1.56138 | 0.00466897 | 36.6514
STAB | ST9 | ST9 | 45.7 | 0 | 2.1 | 6464.8 | 6464.8 | 1.99762 | 0.00597348 | 46.8918
STAB | ST10 | ST10 | 47.5 | 0 | 2.1 | 6714 | 6713.99 | 2.07462 | 0.00620373 | 48.6993
STAB | ST10 | ST10 | 47.5 | 0 | 2.1 | 6713.2 | 6713.2 | 2.07438 | 0.006203 | 48.6935
STAB | ST9 | ST9 | 45.7 | 0 | 2.1 | 6464.8 | 6464.81 | 1.99763 | 0.00597349 | 46.8919
STAB | ST8 | ST8 | 51.4 | 0 | 2.3 | 7269.2 | 7269.24 | 2.24619 | 0.00671677 | 52.7267
STAB | ST7 | ST7 | 52.1 | 0 | 2.4 | 7359.7 | 7359.7 | 2.27415 | 0.00680036 | 53.3829
STAB | ST6 | ST6 | 52.5 | 0 | 2.4 | 7427.6 | 7427.64 | 2.29514 | 0.00686314 | 53.8756
STAB | ST5 | ST5 | 50.9 | 0 | 2.3 | 7203.6 | 7203.58 | 2.22591 | 0.00665611 | 52.2505
STAB | 85 | ST14 | 36.9 | 0.4 | 1.7 | 5215.3 | 5215.3 | 1.61153 | 0.00481894 | 37.8287
2 x STAB | 84 | ST1 | 38.1 | 0.4 | 1.7 | 5390.6 | 5390.6 | 1.6657 | 0.00498091 | 39.1002
STAB | 84 | ST15 | 38.1 | 0.4 | 1.7 | 5390.6 | 5390.6 | 1.6657 | 0.00498091 | 39.1002
3 x STAB | 84 | ST3 | 38.1 | 0.4 | 1.7 | 5390.6 | 5390.6 | 1.6657 | 0.00498091 | 39.1002
2 x STAB | 83 | ST2 | 44.5 | 0.5 | 2 | 6290.6 | 6290.6 | 1.9438 | 0.00581251 | 45.6282
STAB | 85 | ST4 | 36.9 | 0.4 | 1.7 | 5215.3 | 5215.3 | 1.61153 | 0.00481894 | 37.8287

# IfcBeam: UPF-120*50*4 (44)
In: Undefined
Description: UPF-120*50*4; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: UPF-120*50*4; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Hauteur: 120 mm; Largeur: 50 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LINTEAU | 40 | L21 | LINTEAU | 16.2 | 0.3 | 66.6 | 1.1 | 2499.3 | 2499.3 | 1.08139 | 0.00211941 | 16.6373
LINTEAU | 40 | L21 | LINTEAU | 16.2 | 0 | 66.6 | 1.1 | 2499.3 | 2499.3 | 1.08139 | 0.00211941 | 16.6373
LINTEAU | 39 | L25 | LINTEAU | 15.2 | 0 | 66.6 | 1 | 2334 | 2334 | 1.00998 | 0.00197923 | 15.537
15 x LINTEAU | 37 | L22 | LINTEAU | 6.7 | 0 | 66.8 | 0.4 | 1028 | 1028 | 0.445792 | 0.000871744 | 6.84319
2 x LINTEAU | L6 | L6 | LINTEAU | 24.3 | 0 | 66.6 | 1.6 | 3744.7 | 3744.7 | 1.61941 | 0.00317551 | 24.9277
2 x LINTEAU | L6 | L6 | LINTEAU | 24.3 | 0.4 | 66.6 | 1.6 | 3744.7 | 3744.7 | 1.61941 | 0.00317551 | 24.9277
2 x LINTEAU | L2 | L2 | LINTEAU | 17.2 | 0.3 | 66.6 | 1.1 | 2654.3 | 2654.35 | 1.14838 | 0.00223928 | 17.5784
2 x LINTEAU | L8 | L8 | LINTEAU | 17.2 | 0 | 66.6 | 1.1 | 2654.3 | 2654.35 | 1.14838 | 0.00225089 | 17.6695
2 x LINTEAU | L7 | L7 | LINTEAU | 27.4 | 0 | 66.6 | 1.8 | 4212 | 4212 | 1.82128 | 0.00357178 | 28.0384
2 x LINTEAU | L1 | L1 | LINTEAU | 27.4 | 0.5 | 66.6 | 1.8 | 4212 | 4212 | 1.82128 | 0.0035601 | 27.9467
2 x LINTEAU | L5 | L5 | LINTEAU | 26.8 | 0 | 66.6 | 1.8 | 4122.3 | 4122.35 | 1.78255 | 0.00349575 | 27.4417
2 x LINTEAU | L5 | L5 | LINTEAU | 26.8 | 0.5 | 66.6 | 1.8 | 4122.3 | 4122.35 | 1.78255 | 0.00349575 | 27.4417
2 x LINTEAU | 38 | L23 | LINTEAU | 3.4 | 0 | 67 | 0.2 | 528 | 528 | 0.229792 | 0.000447744 | 3.51479
LISSE | 28 | L13 | LISSE | 24.3 | 0 | 66.6 | 1.6 | 3735.2 | 3735.23 | 1.61531 | 0.00316747 | 24.8647
LISSE | 27 | L12 | LISSE | 29.6 | 0 | 66.6 | 2 | 4558.1 | 4558.12 | 1.9708 | 0.00386528 | 30.3425
LISSE | 26 | L14 | LISSE | 28.8 | 0 | 66.6 | 1.9 | 4438.1 | 4438.06 | 1.91894 | 0.00376347 | 29.5433
LISSE | 23 | L9 | LISSE | 28.6 | 0 | 66.6 | 1.9 | 4409.6 | 4409.58 | 1.90615 | 0.00373836 | 29.3461
LISSE | 25 | L11 | LISSE | 40.7 | 0.1 | 66.6 | 2.7 | 6263.4 | 6263.4 | 2.70748 | 0.00531136 | 41.6942
LISSE | 25 | L10 | LISSE | 40.7 | 0.1 | 66.6 | 2.7 | 6263.4 | 6263.4 | 2.70748 | 0.00531136 | 41.6942
POUTRE | 22 | A14 | POUTRE | 8 | 0 | 66.6 | 0.5 | 1235.4 | 1235.44 | 0.534599 | 0.00104607 | 8.21163
POUTRE | 21 | A14 | POUTRE | 8 | 0 | 66.6 | 0.5 | 1235.3 | 1235.34 | 0.534576 | 0.00104602 | 8.21128

# IfcBeam: UPF-200*80*4 (2)
In: Undefined
Description: UPF-200*80*4; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: UPF-200*80*4; Nom: POUTRE; sets with these values: 2
Tekla Quantités - Poids: 100.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.4 m2; Surface nette: 6.6 m2; Hauteur: 200 mm; Largeur: 80 mm; Longueur: 9235.5 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 9235.51 mm; OuterSurfaceArea: 6.57412 m2; NetVolume: 0.0129949 m3; NetWeight: 102.01 kg
Name | Repère de pièce = Reference | Repère d'assemblage
POUTRE | 18 | A2
POUTRE | 17 | A1

# IfcBeam: UPN180, POUTRE
In: Undefined
Description: UPN180; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PT1; Repère d'assemblage: PT1; Phase: 1; Profil: UPN180; Nom: POUTRE; sets with these values: 2
Tekla Quantités - Poids: 51.9 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 27.5 m2; Surface nette: 1.5 m2; Hauteur: 180 mm; Largeur: 70 mm; Longueur: 2368.4 mm; sets with these values: 2
Pset_BeamCommon - LoadBearing: no; Reference: PT1
BaseQuantities - Length: 2368.4 mm; OuterSurfaceArea: 1.42578 m2; NetVolume: 0.00654702 m3; NetWeight: 51.3941 kg

# IfcColumn: HEA120 (3)
In: Undefined
Description: HEA120; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: HEA120; Nom: POTEAU; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 34 m2; Hauteur: 114 mm; Largeur: 120 mm; sets with these values: 2
Pset_ColumnCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU | 82 | P4 | 56.5 | 2 | 2840 | 2840 | 1.92268 | 0.0068444 | 53.7285
POTEAU | 81 | P3 | 122.8 | 4.3 | 6173.6 | 6173.61 | 4.17953 | 0.0148784 | 116.795
POTEAU | 80 | P2 | 123.5 | 4.3 | 6209 | 6208.97 | 4.20347 | 0.0149636 | 117.464

# IfcColumn: IPE180 (7)
In: Undefined
Description: IPE180; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: IPE180; Nom: POTEAU; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 37.2 m2; Hauteur: 180 mm; Largeur: 91 mm; sets with these values: 2
Pset_ColumnCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU | 5 | P29 | 116.5 | 4.4 | 6207.3 | 6207.27 | 4.33267 | 0.0144331 | 113.3
POTEAU | 4 | P28 | 118.7 | 4.5 | 6326 | 6325.97 | 4.41553 | 0.0147091 | 115.467
POTEAU | 2 | P16 | 123.6 | 4.7 | 6587.4 | 6587.44 | 4.59804 | 0.0153171 | 120.239
POTEAU | 3 | P17 | 126.2 | 4.8 | 6728.6 | 6728.6 | 4.69656 | 0.0156453 | 122.816
POTEAU | 2 | P15 | 123.6 | 4.7 | 6587.5 | 6587.46 | 4.59805 | 0.0153172 | 120.24
POTEAU | 1 | P18 | 120.9 | 4.6 | 6446.1 | 6446.15 | 4.49941 | 0.0149886 | 117.66
POTEAU | 1 | P19 | 120.9 | 4.6 | 6446.2 | 6446.18 | 4.49943 | 0.0149887 | 117.661

# IfcColumn: IPE450 (10)
In: Undefined
Description: IPE450; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: IPE450; Nom: POTEAU; sets with these values: 2
Tekla Quantités - Poids: 500.6 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Surface par tonne: 20.7 m2; Surface nette: 10.6 m2; Hauteur: 450 mm; Largeur: 190 mm; Longueur: 6455 mm; sets with these values: 2
Pset_ColumnCommon - LoadBearing: no
BaseQuantities - Length: 6455 mm; OuterSurfaceArea: 10.3603 m2; NetVolume: 0.0613452 m3; NetWeight: 481.56 kg
Name | Repère de pièce = Reference | Repère d'assemblage
POTEAU | 132 | P9
POTEAU | 132 | P6
POTEAU | 132 | P12
POTEAU | 132 | P14
POTEAU | 131 | P8
POTEAU | 132 | P10
POTEAU | 132 | P5
POTEAU | 132 | P11
POTEAU | 132 | P13
POTEAU | 131 | P7

# IfcColumn: UPF-120*50*4 (6)
In: Undefined
Description: UPF-120*50*4; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: UPF-120*50*4; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.6 m2; Hauteur: 120 mm; Largeur: 50 mm; sets with these values: 2
Pset_ColumnCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LINTEAU | L4 | L4 | LINTEAU | 33.8 | 2.2 | 5200.6 | 2.24836 | 0.00441011 | 34.6194
LINTEAU | L3 | L3 | LINTEAU | 33.8 | 2.2 | 5200.6 | 2.24836 | 0.00441011 | 34.6194
3 x POTEAU | 20 | P21 | POTEAU | 14.2 | 0.9 | 2188 | 0.946912 | 0.00185542 | 14.5651
POTEAU | 20 | P21 | POTEAU | 14.2 | 0.9 | 2188 | 0.946913 | 0.00185543 | 14.5651

# IfcColumn: UPF-200*80*4 (7)
In: Undefined
Description: UPF-200*80*4; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: UPF-200*80*4; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Hauteur: 200 mm; Largeur: 80 mm; sets with these values: 2
Pset_ColumnCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x LINTEAU | 19 | L24 | LINTEAU | 43.4 | 0.3 | 65.5 | 2.8 | 3988 | 2.84227 | 0.0056151 | 44.0786
2 x LINTEAU | 19 | L24 | LINTEAU | 43.4 | 0 | 65.5 | 2.8 | 3988 | 2.84227 | 0.0056151 | 44.0786
POTEAU | 16 | P23 | POTEAU | 65.4 | 0 | 65.4 | 4.3 | 6010 | 4.28194 | 0.00846208 | 66.4273
POTEAU | 15 | P22 | POTEAU | 65.4 | 0 | 65.4 | 4.3 | 6010 | 4.28194 | 0.00846208 | 66.4273
POTEAU | 14 | P1 | POTEAU | 65.4 | 0 | 65.4 | 4.3 | 6010 | 4.28194 | 0.00846208 | 66.4273

# IfcColumn: UPN180 (2)
In: Undefined
Description: UPN180; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: UPN180; Nom: POTEAU; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 27.5 m2; Hauteur: 180 mm; Largeur: 70 mm; sets with these values: 2
Pset_ColumnCommon - LoadBearing: no
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU | 7 | P27 | 137.7 | 3.9 | 6286.2 | 6286.16 | 3.78427 | 0.017377 | 136.409
POTEAU | 6 | P20 | 136 | 3.8 | 6210.2 | 6210.2 | 3.73854 | 0.017167 | 134.761

# IfcDiscreteAccessory: AILE_JARRET (10)
In: Undefined
Description: PL10*170; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 43; Phase: 1; Profil: PL10*170; Nom: AILE_JARRET
Tekla Quantités - Poids: 5.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 27.6 m2; Surface nette: 0.1 m2; Hauteur: 170 mm; Largeur: 10 mm; Longueur: 396.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: 43
BaseQuantities - NetArea: 0.146043 m2; GrossArea: 0.146043 m2; CrossSectionArea: 0.0017 m2; NetVolume: 0.000673594 m3; GrossVolume: 0.000673594 m3
Name | Repère d'assemblage
AILE_JARRET | A10
AILE_JARRET | A11
AILE_JARRET | A6
AILE_JARRET | A7
2 x AILE_JARRET | A5
AILE_JARRET | A9
AILE_JARRET | A8
AILE_JARRET | A4
AILE_JARRET | A3

# IfcDiscreteAccessory: AME_JARRET (10)
In: Undefined
Description: PL6*110; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 134; Phase: 1; Profil: PL6*110; Nom: AME_JARRET
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48 m2; Surface nette: 0 m2; Hauteur: 102.5 mm; Largeur: 6 mm; Longueur: 396.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: 134
BaseQuantities - NetArea: 0.0459438 m2; GrossArea: 0.0932458 m2; CrossSectionArea: 0.00066 m2; NetVolume: 0.000121867 m3; GrossVolume: 0.000261513 m3
Name | Repère d'assemblage
AME_JARRET | A10
AME_JARRET | A11
AME_JARRET | A6
AME_JARRET | A7
2 x AME_JARRET | A5
AME_JARRET | A9
AME_JARRET | A8
AME_JARRET | A4
AME_JARRET | A3

# IfcDiscreteAccessory: BARRE (20)
In: Undefined
Description: D22; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 9; Repère d'assemblage: 1; Phase: 1; Profil: D22; Nom: BARRE
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 24.5 m2; Surface nette: 0 m2; Hauteur: 22 mm; Largeur: 22 mm; Longueur: 526.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: 9
BaseQuantities - NetArea: 0.0372007 m2; GrossArea: 0.0372007 m2; CrossSectionArea: 0.000363 m2; NetVolume: 0.000193467 m3; GrossVolume: 0.000193467 m3

# IfcDiscreteAccessory: BECHE (15)
In: Undefined
Description: IPE100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 98; Phase: 1; Profil: IPE100; Nom: BECHE
Tekla Quantités - Poids: 0.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 49.5 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 55 mm; Longueur: 100 mm
Pset_PlateCommon - LoadBearing: no; Reference: 98
BaseQuantities - NetArea: 0.04 m2; GrossArea: 0.04 m2; CrossSectionArea: 0.00103 m2; NetVolume: 0.000099026 m3; GrossVolume: 0.000103 m3
Name | Repère d'assemblage
10 x BECHE | 1
5 x BECHE | 2

# IfcDiscreteAccessory: CAE DP (13)
In: Undefined
Description: L40*4; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: L40*4; Nom: CAE DP
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.1 m2; Hauteur: 40 mm; Largeur: 40 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000308 m2
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface nette (m2) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x CAE DP | 120 | P18 | 5.2 | 0.3 | 2150 | 0.33325 | 0.000653599 | 0.000662199
CAE DP | 124 | P18 | 9.4 | 0.6 | 3907.5 | 0.605668 | 0.00118789 | 0.00120352
CAE DP | 123 | P20 | 17.2 | 1.1 | 7100 | 1.1005 | 0.0021584 | 0.0021868
CAE DP | 121 | P19 | 0.8 | 0.1 | 327.8 | 0.0508164 | 0.0000996657 | 0.000100977
CAE DP | 122 | P19 | 14.9 | 1 | 6147.5 | 0.952868 | 0.00186885 | 0.00189344
CAE DP | 121 | P18 | 0.8 | 0.1 | 327.8 | 0.0508164 | 0.0000996657 | 0.000100977
CAE DP | 119 | P7 | 1.6 | 0.1 | 677 | 0.104936 | 0.000205809 | 0.000208517
CAE DP | 118 | P7 | 13.2 | 0.9 | 5453 | 0.845214 | 0.00165771 | 0.00167952
CAE DP | 117 | P7 | 2.2 | 0.1 | 914 | 0.14167 | 0.000277855 | 0.000281511
CAE DP | 119 | P8 | 1.6 | 0.1 | 677 | 0.104936 | 0.000205809 | 0.000208517
CAE DP | 118 | P8 | 13.2 | 0.9 | 5453 | 0.845214 | 0.00165771 | 0.00167952
CAE DP | 117 | P8 | 2.2 | 0.1 | 914 | 0.14167 | 0.000277855 | 0.000281511

# IfcDiscreteAccessory: GOUSSET GARDE CORPS (6)
In: Undefined
Description: PL10*129; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 68; Repère d'assemblage: PT2; Phase: 1; Profil: PL10*129; Nom: GOUSSET GARDE CORPS
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 29.1 m2; Surface nette: 0 m2; Hauteur: 129.2 mm; Largeur: 10 mm; Longueur: 150 mm
Pset_PlateCommon - LoadBearing: no; Reference: 68
BaseQuantities - NetArea: 0.0440311 m2; GrossArea: 0.01938 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000192675 m3; GrossVolume: 0.000192675 m3

# IfcDiscreteAccessory: HAUNCH (10)
In: Undefined
Description: IPE360; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 109; Phase: 1; Profil: IPE360; Nom: HAUNCH
Tekla Quantités - Poids: 120.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 23.7 m2; Surface nette: 1.4 m2; Hauteur: 347.3 mm; Largeur: 170 mm; Longueur: 2112.7 mm
Pset_PlateCommon - LoadBearing: no; Reference: 109
BaseQuantities - NetArea: 2.85844 m2; GrossArea: 2.85844 m2; CrossSectionArea: 0.00727 m2; NetVolume: 0.0142705 m3; GrossVolume: 0.0153591 m3
Name | Repère d'assemblage
HAUNCH | A9
2 x HAUNCH | A5
HAUNCH | A7
HAUNCH | A11
HAUNCH | A10
HAUNCH | A6
HAUNCH | A8
HAUNCH | A3
HAUNCH | A4

# IfcDiscreteAccessory: HAUNCH_PLATE (3)
In: Undefined
Description: PL10*72; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 52; Phase: 1; Profil: PL10*72; Nom: HAUNCH_PLATE
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 31.5 m2; Surface nette: 0 m2; Hauteur: 72 mm; Largeur: 10 mm; Longueur: 100 mm
Pset_PlateCommon - LoadBearing: no; Reference: 52
BaseQuantities - NetArea: 0.0174106 m2; GrossArea: 0.0072 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00007038 m3; GrossVolume: 0.00007038 m3
Name | Repère d'assemblage
HAUNCH_PLATE | P25
HAUNCH_PLATE | P26
HAUNCH_PLATE | P24

# IfcDiscreteAccessory: LISSE (5)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: LISSE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x LISSE | PL150*10 | 65 | A4 | 4.2 | 27.9 | 0.1 | 150 | 10 | 360.4 | 0.118324 | 0.118324 | 0.0015 | 0.000540583 | 0.000540583
LISSE | TUBE-C-90*90*3 | 164 | P20 | 57.7 | 43.5 | 2.6 | 90 | 90 | 7200 | 2.5128 | 2.5128 | 0.001021 | 0.00746982 | 0.0073512
LISSE | TUBE-C-90*90*3 | 164 | P27 | 57.7 | 43.5 | 2.6 | 90 | 90 | 7200 | 2.5128 | 2.5128 | 0.001021 | 0.00746982 | 0.0073512
LISSE | UPF-120*50*4 | 24 | L9 | 4.3 | 66.8 | 0.3 | 120 | 50 | 667.8 | 0.289708 | 0 | 0.0008274 | 0.000565339 | 0.000552551

# IfcDiscreteAccessory: PLAT (40)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: PLAT
Tekla Quantités - Volume: 0 m3
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLAT | PL10*80 | 168 | P1 | 1.3 | 0 | 29.9 | 0 | 80 | 10 | 200 | 0.0376 | 0.0008 | 0.00016
PLAT | PL6*180 | 139 | L25 | 1 | 0 | 46 | 0 | 180 | 6 | 120 | 0.0468 | 0.00108 | 0.0001296
PLAT | PL10*200 | 140 | P23 | 3.1 | 0 | 28 | 0.1 | 200 | 10 | 200 | 0.088 | 0.002 | 0.0004
PLAT | PL10*200 | 140 | P22 | 3.1 | 0 | 28 | 0.1 | 200 | 10 | 200 | 0.088 | 0.002 | 0.0004
4 x PLAT | PL6*180 | 139 | P21 | 1 | 0 | 46 | 0 | 180 | 6 | 120 | 0.0468 | 0.00108 | 0.0001296
PLAT | PL10*200 | 47 | P2 | 1.8 | 0 | 29 | 0.1 | 200 | 10 | 114 | 0.05188 | 0.002 | 0.000228
PLAT | PL10*200 | 47 | P4 | 1.8 | 0 | 29 | 0.1 | 200 | 10 | 114 | 0.05188 | 0.002 | 0.000228
PLAT | PL10*200 | 47 | P3 | 1.8 | 0 | 29 | 0.1 | 200 | 10 | 114 | 0.05188 | 0.002 | 0.000228
PLAT | PL10*200 | 46 | P20 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 46 | P27 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 46 | P28 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 46 | P29 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL15*180 | 11 | A11 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A10 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A7 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A6 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
2 x PLAT | PL15*180 | 11 | A5 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A8 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A9 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A4 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*180 | 11 | A3 | 10.3 | 0 | 18.9 | 0.2 | 180 | 15 | 485 | 0.19455 | 0.0027 | 0.0013095
PLAT | PL15*200 | 10 | P8 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P9 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P6 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P14 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P12 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P7 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P10 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P5 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL15*200 | 10 | P13 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009
PLAT | PL10*200 | 41 | P18 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 41 | P16 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 41 | P17 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 41 | P15 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL10*200 | 41 | P19 | 2.8 | 0 | 28.2 | 0.1 | 200 | 10 | 180 | 0.0796 | 0.002 | 0.00036
PLAT | PL15*200 | 10 | P11 | 7.1 | 0.1 | 19.1 | 0.1 | 200 | 15 | 300 | 0.135 | 0.003 | 0.0009

# IfcDiscreteAccessory: PLATINE (94)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: PLATINE
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATINE | PL6*100 | 157 | P14 | 0.4 | 48.3 | 0 | 100 | 6 | 80.5 | 0.0173592 | 0.0182554 | 0.0006 | 0.0000457924 | 0.00004827
PLATINE | PL6*100 | 157 | P13 | 0.4 | 48.3 | 0 | 100 | 6 | 80.5 | 0.0173592 | 0.0182554 | 0.0006 | 0.0000457924 | 0.00004827
PLATINE | PL6*100 | 156 | P7 | 0.3 | 49.3 | 0 | 100 | 6 | 60 | 0.01392 | 0.01392 | 0.0006 | 0.000036 | 0.000036
PLATINE | PL6*100 | 153 | P7 | 0.6 | 47.1 | 0 | 100 | 6 | 120 | 0.02664 | 0.02664 | 0.0006 | 0.000072 | 0.000072
PLATINE | PL6*100 | 156 | P8 | 0.3 | 49.3 | 0 | 100 | 6 | 60 | 0.01392 | 0.01392 | 0.0006 | 0.000036 | 0.000036
PLATINE | PL6*100 | 153 | P8 | 0.6 | 47.1 | 0 | 100 | 6 | 120 | 0.02664 | 0.02664 | 0.0006 | 0.000072 | 0.000072
PLATINE | PL6*100 | 155 | P26 | 0.8 | 46.4 | 0 | 100 | 6 | 180 | 0.03936 | 0.03936 | 0.0006 | 0.000108 | 0.000108
PLATINE | PL10*120 | 60 | P4 | 2.6 | 28.5 | 0.1 | 120 | 10 | 280 | 0.0752 | 0.0752 | 0.0012 | 0.000336 | 0.000336
2 x PLATINE | PL6*50 | 136 | L21 | 0.3 | 49.7 | 0 | 50 | 6 | 120 | 0.01404 | 0.01404 | 0.0003 | 0.000036 | 0.000036
30 x PLATINE | PL6*50 | 136 | L22 | 0.3 | 49.7 | 0 | 50 | 6 | 120 | 0.01404 | 0.01404 | 0.0003 | 0.000036 | 0.000036
4 x PLATINE | PL6*50 | 136 | L23 | 0.3 | 49.7 | 0 | 50 | 6 | 120 | 0.01404 | 0.01404 | 0.0003 | 0.000036 | 0.000036
2 x PLATINE | PL6*100 | 138 | P17 | 0.3 | 49.3 | 0 | 100 | 6 | 60 | 0.01392 | 0.01392 | 0.0006 | 0.000036 | 0.000036
PLATINE | PL6*100 | 138 | P19 | 0.3 | 49.3 | 0 | 100 | 6 | 60 | 0.01392 | 0.01392 | 0.0006 | 0.000036 | 0.000036
PLATINE | PL6*100 | 154 | P19 | 0.6 | 47.1 | 0 | 100 | 6 | 120 | 0.02664 | 0.02664 | 0.0006 | 0.000072 | 0.000072
PLATINE | PL6*100 | 138 | P18 | 0.3 | 49.3 | 0 | 100 | 6 | 60 | 0.01392 | 0.01392 | 0.0006 | 0.000036 | 0.000036
PLATINE | PL6*100 | 154 | P18 | 0.6 | 47.1 | 0 | 100 | 6 | 120 | 0.02664 | 0.02664 | 0.0006 | 0.000072 | 0.000072
PLATINE | PL6*100 | 154 | P6 | 0.6 | 47.1 | 0 | 100 | 6 | 120 | 0.02664 | 0.02664 | 0.0006 | 0.000072 | 0.000072
PLATINE | PL6*100 | 154 | P5 | 0.6 | 47.1 | 0 | 100 | 6 | 120 | 0.02664 | 0.02664 | 0.0006 | 0.000072 | 0.000072
2 x PLATINE | PL10*80 | 53 | ST14 | 1.4 | 29.8 | 0 | 80 | 10 | 230 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
PLATINE | PL10*80 | 54 | A2 | 1.7 | 29.6 | 0 | 80 | 10 | 265 | 0.0493 | 0.0493 | 0.0008 | 0.000212 | 0.000212
2 x PLATINE | PL10*80 | 53 | ST4 | 1.4 | 29.8 | 0 | 80 | 10 | 230 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
PLATINE | PL10*80 | 54 | A1 | 1.7 | 29.6 | 0 | 80 | 10 | 265 | 0.0493 | 0.0493 | 0.0008 | 0.000212 | 0.000212
PLATINE | PL10*230 | 51 | P25 | 3 | 28.1 | 0.1 | 230 | 10 | 168 | 0.08524 | 0.08524 | 0.0023 | 0.0003864 | 0.0003864
PLATINE | PL10*230 | 51 | P26 | 3 | 28.1 | 0.1 | 230 | 10 | 168 | 0.08524 | 0.08524 | 0.0023 | 0.0003864 | 0.0003864
PLATINE | PL10*230 | 51 | P24 | 3 | 28.1 | 0.1 | 230 | 10 | 168 | 0.08524 | 0.08524 | 0.0023 | 0.0003864 | 0.0003864
8 x PLATINE | PL6*80 | 137 | L24 | 0.8 | 46.9 | 0 | 80 | 6 | 200 | 0.03536 | 0.03536 | 0.00048 | 0.000096 | 0.000096
4 x PLATINE | PL6*50 | 136 | P21 | 0.3 | 49.7 | 0 | 50 | 6 | 120 | 0.01404 | 0.01404 | 0.0003 | 0.000036 | 0.000036
PLATINE | PL10*91 | 48 | P18 | 1.2 | 29.8 | 0 | 91 | 10 | 170 | 0.03616 | 0.03616 | 0.00091 | 0.0001547 | 0.0001547
PLATINE | PL10*91 | 48 | P16 | 1.2 | 29.8 | 0 | 91 | 10 | 170 | 0.03616 | 0.03616 | 0.00091 | 0.0001547 | 0.0001547
PLATINE | PL10*91 | 48 | P17 | 1.2 | 29.8 | 0 | 91 | 10 | 170 | 0.03616 | 0.03616 | 0.00091 | 0.0001547 | 0.0001547
PLATINE | PL10*91 | 48 | P15 | 1.2 | 29.8 | 0 | 91 | 10 | 170 | 0.03616 | 0.03616 | 0.00091 | 0.0001547 | 0.0001547
PLATINE | PL10*91 | 48 | P19 | 1.2 | 29.8 | 0 | 91 | 10 | 170 | 0.03616 | 0.03616 | 0.00091 | 0.0001547 | 0.0001547
4 x PLATINE | PL10*80 | 53 | ST1 | 1.4 | 29.8 | 0 | 80 | 10 | 230 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
2 x PLATINE | PL10*80 | 53 | ST15 | 1.4 | 29.8 | 0 | 80 | 10 | 230 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
6 x PLATINE | PL10*80 | 53 | ST3 | 1.4 | 29.8 | 0 | 80 | 10 | 230 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184
4 x PLATINE | PL10*80 | 53 | ST2 | 1.4 | 29.8 | 0 | 80 | 10 | 230 | 0.043 | 0.043 | 0.0008 | 0.000184 | 0.000184

# IfcDiscreteAccessory: PLATS (7)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: PLATS
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x PLATS | PL60*10 | PLATS1 | PLATS1 | 5.7 | 30 | 0.2 | 60 | 1238.2 | 0.171214 | 0.174548 | 0.0006 | 0.00072822 | 0.00074292
PLATS | PL90*10 | 66 | P18 | 1.2 | 29.9 | 0 | 90 | 164 | 0.0346 | 0.0346 | 0.0009 | 0.0001476 | 0.0001476

# IfcDiscreteAccessory: POTEAU (6)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
POTEAU | IPE100 | 105 | P19 | 2.7 | 49.5 | 0.1 | 100 | 55 | 330.6 | 0.132239 | 0.132239 | 0.00103 | 0.000326581 | 0.000340516
POTEAU | IPE100 | 105 | P18 | 2.7 | 49.5 | 0.1 | 100 | 55 | 330.6 | 0.132231 | 0.132231 | 0.00103 | 0.000326561 | 0.000340496
POTEAU | IPE100 | 103 | P16 | 2.6 | 49.5 | 0.1 | 100 | 55 | 327.5 | 0.131015 | 0.131015 | 0.00103 | 0.000324348 | 0.000337364
POTEAU | IPE100 | 104 | P17 | 2.5 | 49.5 | 0.1 | 100 | 55 | 314.8 | 0.125903 | 0.125903 | 0.00103 | 0.000311692 | 0.000324201
POTEAU | IPE100 | 103 | P15 | 2.6 | 49.5 | 0.1 | 100 | 55 | 327.5 | 0.131009 | 0.131009 | 0.00103 | 0.000324332 | 0.000337348
POTEAU | UPF-200*80*4 | 13 | P9 | 64 | 65.4 | 4.2 | 200 | 80 | 5880 | 4.18938 | 0 | 0.001387 | 0.00827904 | 0.00815556

# IfcDiscreteAccessory: POUTRE (19)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: POUTRE
Tekla Quantités - Volume: 0 m3
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
POUTRE | L40*4 | 116 | L14 | 10.1 | 0 | 64.1 | 0.7 | 40 | 40 | 4169.5 | 0.646266 | 0.646266 | 0.000308 | 0.00126751 | 0.00128419
POUTRE | L40*4 | 115 | L13 | 8.4 | 0 | 64.1 | 0.6 | 40 | 40 | 3486.6 | 0.540428 | 0.540428 | 0.000308 | 0.00105994 | 0.00107388
POUTRE | L40*4 | 114 | L12 | 10.4 | 0 | 64.1 | 0.7 | 40 | 40 | 4289.5 | 0.664874 | 0.664874 | 0.000308 | 0.00130401 | 0.00132117
POUTRE | L40*4 | 113 | L9 | 1.3 | 0 | 64.1 | 0.1 | 40 | 40 | 542.8 | 0.0841406 | 0.0841406 | 0.000308 | 0.000164917 | 0.000167195
POUTRE | L40*4 | 112 | L11 | 14.5 | 0.2 | 64.1 | 1 | 40 | 40 | 5985.9 | 0.927815 | 0.927815 | 0.000308 | 0.00181971 | 0.00184366
POUTRE | L40*4 | 111 | L10 | 14.5 | 0.2 | 64.1 | 1 | 40 | 40 | 6013.4 | 0.932077 | 0.932077 | 0.000308 | 0.00182807 | 0.00185213
POUTRE | L40*4 | 110 | L9 | 10.4 | 0 | 64.1 | 0.7 | 40 | 40 | 4284.6 | 0.664115 | 0.664115 | 0.000308 | 0.00130241 | 0.00131966
POUTRE | IPE100 | 102 | P13 | 7.4 | 0 | 49.5 | 0.4 | 100 | 55 | 920 | 0.367999 | 0.367999 | 0.00103 | 0.000911037 | 0.000947597
POUTRE | IPE100 | 100 | P7 | 7.4 | 0 | 49.5 | 0.4 | 100 | 55 | 914 | 0.365599 | 0.365599 | 0.00103 | 0.000905095 | 0.000941417
POUTRE | IPE100 | 102 | P14 | 7.4 | 0 | 49.5 | 0.4 | 100 | 55 | 920 | 0.367999 | 0.367999 | 0.00103 | 0.000911037 | 0.000947597
POUTRE | IPE100 | 100 | P8 | 7.4 | 0 | 49.5 | 0.4 | 100 | 55 | 914 | 0.365599 | 0.365599 | 0.00103 | 0.000905095 | 0.000941417
POUTRE | IPE100 | 101 | P10 | 2.6 | 0 | 49.5 | 0.1 | 100 | 55 | 320 | 0.127999 | 0.127999 | 0.00103 | 0.000316881 | 0.000329597
POUTRE | IPE100 | 99 | P5 | 2.5 | 0 | 49.5 | 0.1 | 100 | 55 | 314 | 0.125599 | 0.125599 | 0.00103 | 0.000310939 | 0.000323417
POUTRE | IPE100 | 101 | P11 | 2.6 | 0 | 49.5 | 0.1 | 100 | 55 | 320 | 0.127999 | 0.127999 | 0.00103 | 0.000316881 | 0.000329597
POUTRE | IPE100 | 101 | P9 | 2.6 | 0 | 49.5 | 0.1 | 100 | 55 | 320 | 0.127999 | 0.127999 | 0.00103 | 0.000316881 | 0.000329597
POUTRE | IPE100 | 99 | P6 | 2.5 | 0 | 49.5 | 0.1 | 100 | 55 | 314 | 0.125599 | 0.125599 | 0.00103 | 0.000310939 | 0.000323417
POUTRE | IPE100 | 101 | P12 | 2.6 | 0 | 49.5 | 0.1 | 100 | 55 | 320 | 0.127999 | 0.127999 | 0.00103 | 0.000316881 | 0.000329597
POUTRE | UPF-120*50*4 | 21 | A14 | 8 | 0 | 66.6 | 0.5 | 120 | 50 | 1235.4 | 0.534599 | 0 | 0.0008274 | 0.00104607 | 0.00102221
POUTRE | UPF-120*50*4 | 22 | A14 | 8 | 0 | 66.6 | 0.5 | 120 | 50 | 1235.4 | 0.534599 | 0 | 0.0008274 | 0.00104607 | 0.00102221

# IfcDiscreteAccessory: PRESCEL (15)
In: Undefined
Description: PL6*200; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 133; Phase: 1; Profil: PL6*200; Nom: PRESCEL
Tekla Quantités - Poids: 1.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 45.9 m2; Surface nette: 0.1 m2; Hauteur: 200 mm; Largeur: 6 mm; Longueur: 120 mm
Pset_PlateCommon - LoadBearing: no; Reference: 133
BaseQuantities - NetArea: 0.05184 m2; GrossArea: 0.05184 m2; CrossSectionArea: 0.0012 m2; NetVolume: 0.000144 m3; GrossVolume: 0.000144 m3
Name | Repère d'assemblage
10 x PRESCEL | 1
5 x PRESCEL | 2

# IfcDiscreteAccessory: RAIDISSEUR (42)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: RAIDISSEUR
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Largeur: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000036 m2
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Hauteur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x RAIDISSEUR | PL6*95 | 146 | P13 | 0.7 | 46.6 | 95.4 | 165 | 0.0341365 | 0.015741 | 0.000093246
8 x RAIDISSEUR | PL6*102 | 152 | P28 | 0.6 | 47 | 102 | 125 | 0.0277537 | 0.01275 | 0.0000753
8 x RAIDISSEUR | PL6*102 | 152 | P29 | 0.6 | 47 | 102 | 125 | 0.0277537 | 0.01275 | 0.0000753
4 x RAIDISSEUR | PL6*99 | 151 | P27 | 0.7 | 46.7 | 99 | 150 | 0.0322177 | 0.01485 | 0.0000879
4 x RAIDISSEUR | PL6*99 | 151 | P20 | 0.7 | 46.7 | 99 | 150 | 0.0322177 | 0.01485 | 0.0000879
RAIDISSEUR | PL6*97 | 150 | P7 | 0.8 | 46.5 | 96.5 | 180 | 0.0377803 | 0.01737 | 0.000103545
RAIDISSEUR | PL6*97 | 150 | P8 | 0.8 | 46.5 | 96.5 | 180 | 0.0377803 | 0.01737 | 0.000103545
RAIDISSEUR | PL6*62 | 149 | P24 | 0.5 | 47.9 | 62 | 180 | 0.0249463 | 0.01116 | 0.000066285
RAIDISSEUR | PL6*62 | 148 | P24 | 0.5 | 47.9 | 62 | 180 | 0.0249463 | 0.01116 | 0.000066285
RAIDISSEUR | PL6*62 | 148 | P26 | 0.5 | 47.9 | 62 | 180 | 0.0249463 | 0.01116 | 0.000066285
RAIDISSEUR | PL6*62 | 149 | P26 | 0.5 | 47.9 | 62 | 180 | 0.0249463 | 0.01116 | 0.000066285
RAIDISSEUR | PL6*62 | 149 | P25 | 0.5 | 47.9 | 62 | 180 | 0.0249463 | 0.01116 | 0.000066285
RAIDISSEUR | PL6*62 | 148 | P25 | 0.5 | 47.9 | 62 | 180 | 0.0249463 | 0.01116 | 0.000066285
RAIDISSEUR | PL6*64 | 147 | P8 | 0.5 | 48 | 64.3 | 160 | 0.0229899 | 0.010288 | 0.000061053
RAIDISSEUR | PL6*64 | 147 | P14 | 0.5 | 48 | 64.3 | 160 | 0.0229899 | 0.010288 | 0.000061053
RAIDISSEUR | PL6*64 | 147 | P7 | 0.5 | 48 | 64.3 | 160 | 0.0229899 | 0.010288 | 0.000061053
RAIDISSEUR | PL6*64 | 147 | P13 | 0.5 | 48 | 64.3 | 160 | 0.0229899 | 0.010288 | 0.000061053
RAIDISSEUR | PL6*95 | 146 | P11 | 0.7 | 46.6 | 95.4 | 165 | 0.0341365 | 0.015741 | 0.000093246
RAIDISSEUR | PL6*95 | 146 | P14 | 0.7 | 46.6 | 95.4 | 165 | 0.0341365 | 0.015741 | 0.000093246
RAIDISSEUR | PL6*95 | 146 | P12 | 0.7 | 46.6 | 95.4 | 165 | 0.0341365 | 0.015741 | 0.000093246

# IfcDiscreteAccessory: STANDARD (24)
In: Undefined
Description: PL120*10; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: PL120*10; Nom: STANDARD
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 120 mm; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.0012 m2
Name | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
STANDARD | 49 | P18 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | P16 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
2 x STANDARD | 50 | ST1 | 4.2 | 28.2 | 0.1 | 450 | 0.1194 | 0.00054
STANDARD | 49 | P6 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | P9 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | P5 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | P10 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | A1 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | A10 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | A2 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 49 | A11 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
2 x STANDARD | 49 | A7 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 50 | A11 | 4.2 | 28.2 | 0.1 | 450 | 0.1194 | 0.000540002
2 x STANDARD | 49 | A6 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 50 | A10 | 4.2 | 28.2 | 0.1 | 450 | 0.1194 | 0.000540002
2 x STANDARD | 49 | A9 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 50 | A4 | 4.2 | 28.2 | 0.1 | 450 | 0.1194 | 0.000540002
2 x STANDARD | 49 | A8 | 1.4 | 29.3 | 0 | 150 | 0.0414 | 0.00018
STANDARD | 50 | A3 | 4.2 | 28.2 | 0.1 | 450 | 0.1194 | 0.000540002

# IfcDiscreteAccessory: TOLE (134)
In: Undefined
Material: STEEL/S235JR
Tekla Commun - Phase: 1; Nom: TOLE
Tekla Quantités - Volume: 0 m3
Pset_PlateCommon - LoadBearing: no
Name | Description = Profil | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
TOLE | PL10*70 | 64 | A9 | 0.9 | 0 | 30.6 | 0 | 70 | 10 | 171.5 | 0.028836 | 0.0120032 | 0.0001 | 0.000120032
TOLE | PL10*70 | 64 | A8 | 0.9 | 0 | 30.6 | 0 | 70 | 10 | 171.9 | 0.0289098 | 0.0120355 | 0.0001 | 0.000120355
TOLE | PL6*80 | 145 | PT13 | 0.4 | 0 | 48.2 | 0 | 80 | 6 | 100 | 0.01816 | 0.008 | 0.000036 | 0.000048
TOLE | PL10*140 | 63 | PT10 | 1.8 | 0 | 28.9 | 0.1 | 140 | 10 | 160 | 0.0508 | 0.0224 | 0.0001 | 0.000224
TOLE | PL10*140 | 63 | PT9 | 1.8 | 0 | 28.9 | 0.1 | 140 | 10 | 160 | 0.0508 | 0.0224 | 0.0001 | 0.000224
4 x TOLE | PL6*80 | 144 | P7 | 0.4 | 0 | 48.2 | 0 | 80 | 6 | 100 | 0.01816 | 0.008 | 0.000036 | 0.000048
4 x TOLE | PL6*80 | 144 | P8 | 0.4 | 0 | 48.2 | 0 | 80 | 6 | 100 | 0.01816 | 0.008 | 0.000036 | 0.000048
2 x TOLE | PL10*150 | 59 | P3 | 2.6 | 0 | 28.3 | 0.1 | 150 | 10 | 220 | 0.0734 | 0.033 | 0.0001 | 0.00033
2 x TOLE | PL10*150 | 59 | P2 | 2.6 | 0 | 28.3 | 0.1 | 150 | 10 | 220 | 0.0734 | 0.033 | 0.0001 | 0.00033
TOLE | PL10*180 | 55 | P2 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*140 | 56 | P20 | 2.4 | 0 | 28.5 | 0.1 | 140 | 10 | 220 | 0.0688 | 0.0308 | 0.0001 | 0.000308
TOLE | PL10*140 | 56 | P27 | 2.4 | 0 | 28.5 | 0.1 | 140 | 10 | 220 | 0.0688 | 0.0308 | 0.0001 | 0.000308
5 x TOLE | PL10*180 | 55 | PT2 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*100 | 58 | P8 | 1.7 | 0 | 29.2 | 0.1 | 100 | 10 | 220 | 0.0504 | 0.022 | 0.0001 | 0.00022
TOLE | PL10*100 | 58 | P14 | 1.7 | 0 | 29.2 | 0.1 | 100 | 10 | 220 | 0.0504 | 0.022 | 0.0001 | 0.00022
TOLE | PL10*100 | 58 | P13 | 1.7 | 0 | 29.2 | 0.1 | 100 | 10 | 220 | 0.0504 | 0.022 | 0.0001 | 0.00022
TOLE | PL10*100 | 58 | P7 | 1.7 | 0 | 29.2 | 0.1 | 100 | 10 | 220 | 0.0504 | 0.022 | 0.0001 | 0.00022
TOLE | PL10*160 | 57 | P20 | 2.8 | 0 | 28.2 | 0.1 | 160 | 10 | 220 | 0.078 | 0.0352 | 0.0001 | 0.000352
TOLE | PL10*160 | 57 | P27 | 2.8 | 0 | 28.2 | 0.1 | 160 | 10 | 220 | 0.078 | 0.0352 | 0.0001 | 0.000352
2 x TOLE | PL10*140 | 56 | P28 | 2.4 | 0 | 28.5 | 0.1 | 140 | 10 | 220 | 0.0688 | 0.0308 | 0.0001 | 0.000308
2 x TOLE | PL10*140 | 56 | P29 | 2.4 | 0 | 28.5 | 0.1 | 140 | 10 | 220 | 0.0688 | 0.0308 | 0.0001 | 0.000308
2 x TOLE | PL10*180 | 55 | PT5 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
2 x TOLE | PL10*180 | 55 | PT3 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*180 | 55 | PT8 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
2 x TOLE | PL10*180 | 55 | PT6 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
2 x TOLE | PL10*180 | 55 | PT4 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*180 | 55 | PT7 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*180 | 55 | P7 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*180 | 55 | P13 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*180 | 55 | P8 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
TOLE | PL10*180 | 55 | P14 | 3.1 | 0 | 28.1 | 0.1 | 180 | 10 | 220 | 0.0872 | 0.0396 | 0.0001 | 0.000396
2 x TOLE | PL6*70 | 135 | L19 | 0.2 | 0 | 49.6 | 0 | 70 | 6 | 72.6 | 0.0118705 | 0.00507986 | 0.000036 | 0.0000304791
2 x TOLE | PL6*70 | 135 | L18 | 0.2 | 0 | 49.6 | 0 | 70 | 6 | 72 | 0.011784 | 0.00504 | 0.000036 | 0.00003024
2 x TOLE | PL6*80 | 143 | PA2 | 0.6 | 0 | 47.2 | 0 | 80 | 6 | 165 | 0.02934 | 0.0132 | 0.000036 | 0.0000791999
2 x TOLE | PL6*80 | 143 | PA1 | 0.6 | 0 | 47.2 | 0 | 80 | 6 | 165 | 0.02934 | 0.0132 | 0.000036 | 0.0000792
4 x TOLE | PL6*80 | 142 | A14 | 0.7 | 0 | 47.1 | 0 | 80 | 6 | 180 | 0.03192 | 0.0144 | 0.000036 | 0.0000864
2 x TOLE | PL6*70 | 135 | L16 | 0.2 | 0 | 49.6 | 0 | 70 | 6 | 72 | 0.011784 | 0.00504 | 0.000036 | 0.00003024
2 x TOLE | PL6*70 | 135 | L15 | 0.2 | 0 | 49.6 | 0 | 70 | 6 | 72 | 0.011784 | 0.00504 | 0.000036 | 0.00003024
TOLE | PL6*70 | 135 | L20 | 0.2 | 0 | 49.6 | 0 | 70 | 6 | 72 | 0.011784 | 0.00504 | 0.000036 | 0.00003024
TOLE | PL6*70 | 135 | L17 | 0.2 | 0 | 49.6 | 0 | 70 | 6 | 72 | 0.011784 | 0.00504 | 0.000036 | 0.00003024
2 x TOLE | PL6*70 | 141 | ST15 | 0.6 | 0 | 47.6 | 0 | 70 | 6 | 170 | 0.02668 | 0.0119 | 0.000036 | 0.0000714
TOLE | PL6*70 | 141 | ST14 | 0.6 | 0 | 47.6 | 0 | 70 | 6 | 170 | 0.02668 | 0.0119 | 0.000036 | 0.0000714
TOLE | PL10*122 | 61 | A3 | 1.4 | 0 | 29.3 | 0 | 121.9 | 10 | 150 | 0.0420147 | 0.0182881 | 0.0001 | 0.000182881
TOLE | PL10*120 | 62 | A3 | 1.4 | 0 | 29.3 | 0 | 120 | 10 | 150 | 0.0413849 | 0.0179929 | 0.0001 | 0.000179929
2 x TOLE | PL10*121 | 61 | A4 | 1.4 | 0 | 29.3 | 0 | 121 | 10 | 150 | 0.0417278 | 0.0181537 | 0.0001 | 0.000181537
2 x TOLE | PL10*90 | 45 | P14 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A9 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P14 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P12 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
2 x TOLE | PL15*180 | 12 | A5 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P12 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P6 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A7 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P6 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P9 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A11 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P9 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P10 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A10 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P10 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P5 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A6 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P5 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P11 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL10*190 | 44 | P11 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P13 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A8 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P13 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P7 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A3 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P7 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 45 | P8 | 2.9 | 0 | 28.9 | 0.1 | 90 | 10 | 420.8 | 0.084832 | 0.037872 | 0.0001 | 0.00037431
TOLE | PL15*180 | 12 | A4 | 15.2 | 0 | 18.8 | 0.3 | 180 | 15 | 719.4 | 0.285983 | 0.285983 | 0.0027 | 0.0019425
TOLE | PL10*190 | 44 | P8 | 6.6 | 0.1 | 27.4 | 0.2 | 190 | 10 | 440 | 0.1798 | 0.1798 | 0.0019 | 0.000836
2 x TOLE | PL10*90 | 42 | P8 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P9 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P6 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P14 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P12 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P7 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P10 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P5 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P13 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325
2 x TOLE | PL10*90 | 42 | P11 | 1.7 | 0 | 29.3 | 0 | 90 | 10 | 240.5 | 0.0491287 | 0.021645 | 0.0001 | 0.000213325

# IfcElementAssembly (228)
In: Undefined
PredefinedType: RIGID_FRAME
Tekla Assemblages - sets with these values: 2
Name | Poids Assemblage/Elément béton (kg) | Nom Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
Steel Assembly | 66.6926 | POTEAU | P1 | 80
2 x Steel Assembly | 9.58598 | PLATS | PLATS4 | 21.3
2 x Steel Assembly | 7.45279 | PLATS | PLATS3 | 70
Steel Assembly | 386.554 | POUTRE | PT2 | 315.8
6 x Steel Assembly | 5.71653 | PLATS | PLATS1 | 10
Steel Assembly | 36.5062 | PLATS | PLATS2 | 52
Steel Assembly | 151.709 | POTEAU | P18 | 222.65
Steel Assembly | 668.144 | POUTRE | A4 | 219
Steel Assembly | 221.653 | POTEAU | P20 | 233
Steel Assembly | 17.1664 | CAE DP | A12 | 40
Steel Assembly | 206.15 | POTEAU | P27 | 233
Steel Assembly | 537.335 | POTEAU | P14 | 354.4
Steel Assembly | 538.799 | POTEAU | P13 | 354.4
Steel Assembly | 556.394 | POTEAU | P7 | 284.7
Steel Assembly | 556.394 | POTEAU | P8 | 284.7
Steel Assembly | 16.445 | BAILLONNETTE | P26 | 365.199
Steel Assembly | 656.336 | POUTRE | A9 | 214
Steel Assembly | 656.338 | POUTRE | A8 | 214
Steel Assembly | 60.9204 | POTEAU | P4 | 200
Steel Assembly | 220.551 | POUTRE | PT13 | 157.5
Steel Assembly | 16.1769 | LINTEAU | L25 | 180
2 x Steel Assembly | 16.5158 | LINTEAU | L21 | 50
15 x Steel Assembly | 7.24215 | LINTEAU | L22 | 50
9 x Steel Assembly | 5.94873 | LINTEAU | L26 | 40
Steel Assembly | 218.596 | POUTRE | PT10 | 230.8
Steel Assembly | 220.531 | POUTRE | PT9 | 230.8
Steel Assembly | 131.075 | POTEAU | P28 | 285.3
Steel Assembly | 128.848 | POTEAU | P29 | 285.3
2 x Steel Assembly | 3.99461 | LINTEAU | L23 | 50
4 x Steel Assembly | 24.3222 | LINTEAU | L6 | 50
2 x Steel Assembly | 17.2402 | LINTEAU | L2 | 50
2 x Steel Assembly | 17.2402 | LINTEAU | L8 | 50
2 x Steel Assembly | 27.3573 | LINTEAU | L7 | 50
2 x Steel Assembly | 27.3573 | LINTEAU | L1 | 50
4 x Steel Assembly | 26.775 | LINTEAU | L5 | 50
Steel Assembly | 129.776 | POTEAU | P3 | 305
Steel Assembly | 133.588 | POTEAU | P2 | 305
Steel Assembly | 156.378 | POUTRE | PT5 | 250.8
Steel Assembly | 157.622 | POUTRE | PT3 | 250.8
Steel Assembly | 98.5687 | POUTRE | PT8 | 250.8
Steel Assembly | 140.784 | POUTRE | PT6 | 250.8
Steel Assembly | 154.211 | POUTRE | PT4 | 250.8
Steel Assembly | 111.834 | POUTRE | PT7 | 250.8
Steel Assembly | 68.5766 | POTEAU | P23 | 200
Steel Assembly | 68.5766 | POTEAU | P22 | 200
2 x Steel Assembly | 82.8259 | LISSE | L19 | 100
Steel Assembly | 133.389 | POTEAU | P17 | 200
Steel Assembly | 144.157 | POTEAU | P19 | 200
Steel Assembly | 528.007 | POTEAU | P6 | 224.697
Steel Assembly | 528.007 | POTEAU | P5 | 224.697
2 x Steel Assembly | 96.9313 | LISSE | L18 | 100
Steel Assembly | 40.3363 | STAB | ST14 | 170
Steel Assembly | 103.633 | POUTRE | A2 | 124
Steel Assembly | 39.7758 | STAB | ST4 | 80
Steel Assembly | 103.633 | POUTRE | A1 | 124
2 x Steel Assembly | 123.204 | PANNE | PA2 | 199.2
2 x Steel Assembly | 57.6645 | PANNE | PA1 | 199.2
Steel Assembly | 17.4051 | POUTRE | A14 | 184
Steel Assembly | 17.4044 | POUTRE | A14 | 184
2 x Steel Assembly | 97.0879 | LISSE | L16 | 100
2 x Steel Assembly | 57.8913 | LISSE | L15 | 100
Steel Assembly | 88.4074 | LISSE | L20 | 100
Steel Assembly | 75.3419 | LISSE | L17 | 100
Steel Assembly | 38.9065 | LISSE | L14 | 90.0019
Steel Assembly | 32.6906 | LISSE | L13 | 90.0041
Steel Assembly | 39.9766 | LISSE | L12 | 90.0086
Steel Assembly | 44.65 | LISSE | L9 | 123.287
Steel Assembly | 17.6149 | BAILLONNETTE | P24 | 365.199
Steel Assembly | 17.6764 | BAILLONNETTE | P25 | 365.199
Steel Assembly | 55.1541 | LISSE | L11 | 90
Steel Assembly | 55.2206 | LISSE | L10 | 90
Steel Assembly | 42.1367 | STAB | ST15 | 170
4 x Steel Assembly | 44.9283 | LINTEAU | L24 | 80
4 x Steel Assembly | 15.5112 | POTEAU | P21 | 180
Steel Assembly | 131.692 | POTEAU | P16 | 222.65
Steel Assembly | 49.7041 | STAB | ST13 | 80
Steel Assembly | 526.81 | POTEAU | P11 | 269.7
Steel Assembly | 526.81 | POTEAU | P12 | 269.7
Steel Assembly | 130.279 | POTEAU | P15 | 200
Steel Assembly | 33.7784 | LINTEAU | L4 | 50
2 x Steel Assembly | 45.2547 | STAB | ST1 | 80
Steel Assembly | 591.512 | POTEAU | P9 | 304.7
4 x Steel Assembly | 42.6479 | STAB | ST12 | 80
Steel Assembly | 527.491 | POTEAU | P10 | 224.7
Steel Assembly | 33.7784 | LINTEAU | L3 | 50
Steel Assembly | 658.22 | POUTRE | A10 | 248
2 x Steel Assembly | 35.7391 | STAB | ST11 | 80
