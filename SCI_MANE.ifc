Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcElementAssembly (228)
Name | Poids Assemblage/Elément béton (kg) | Nom Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
Steel Assembly | 658.22 | POUTRE | A11 | 248
Steel Assembly | 655.394 | POUTRE | A7 | 214
Steel Assembly | 655.394 | POUTRE | A6 | 214
2 x Steel Assembly | 45.7246 | STAB | ST9 | 80
Steel Assembly | 47.487 | STAB | ST10 | 80
Steel Assembly | 47.4815 | STAB | ST10 | 80
Steel Assembly | 659.655 | POUTRE | A3 | 214
Steel Assembly | 51.4142 | STAB | ST8 | 80
Steel Assembly | 52.0541 | STAB | ST7 | 80
Steel Assembly | 52.5346 | STAB | ST6 | 80
Steel Assembly | 50.9499 | STAB | ST5 | 80
8 x Steel Assembly | 122.582 | PANNE | PA6 | 64
8 x Steel Assembly | 57.0428 | PANNE | PA4 | 64
10 x Steel Assembly | 112.272 | PANNE | PA7 | 64
3 x Steel Assembly | 41.0157 | STAB | ST3 | 80
2 x Steel Assembly | 47.3813 | STAB | ST2 | 80
Steel Assembly | 51.8715 | POUTRE | PT1 | 70
7 x Steel Assembly | 220.275 | POUTRE | PT12 | 135
Steel Assembly | 220.174 | POUTRE | PT11 | 135
2 x Steel Assembly | 40.0595 | PANNE | PA3 | 64
2 x Steel Assembly | 105.599 | PANNE | PA5 | 64
2 x Steel Assembly | 652.568 | POUTRE | A5 | 180
10 x Steel Assembly | 4.97638 | PRESCEL | 1 | 400
5 x Steel Assembly | 1.93895 | PRESCEL | 2 | 106
10 x Steel Assembly | 1.51872 | BARRE | B1 | 22

# IfcMechanicalFastener: Bolt assembly (439)
In: Undefined
Tekla Boulons - sets with these values: 2
Name | NominalDiameter (mm) | NominalLength (mm) = Longueur (mm) | Material = Standard | Diamètre (mm) | Nom
3 x Bolt assembly | 12 | 10 | 6.8 | 16 | Boulons tête H
16 x Bolt assembly | 12 | 25 | 8.8 | 12 | Boulons tête H
244 x Bolt assembly | 12 | 25 | 6.8 | 12 | Boulons tête H
8 x Bolt assembly | 12 | 6 | 6.8 | 14 | Boulons tête H
4 x Bolt assembly | 16 | 35 | 8.8 | 16 | Boulons tête H
39 x Bolt assembly | 16 | 40 | 6.8 | 16 | Boulons tête H
5 x Bolt assembly | 12 | 6 | 6.8 | 16 | Boulons tête H
22 x Bolt assembly | 16 | 40 | 8.8 | 16 | Boulons tête H
58 x Bolt assembly | 12 | 30 | 6.8 | 12 | Boulons tête H
3 x Bolt assembly | 12 | 40 | 6.8 | 12 | Boulons tête H
7 x Bolt assembly | 12 | 89.2 | HILTI-HSA | 12
15 x Bolt assembly | 16 | 60 | HR10.9 | 16 | Boulons HR tête H
10 x Bolt assembly | 22 | 21 | 6.8 | 40 | Boulons tête H
5 x Bolt assembly | 22 | 16 | 6.8 | 40 | Boulons tête H

# IfcMember: TUBE-C-80*80*3 (5)
In: Undefined
Description: TUBE-C-80*80*3; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Profil: TUBE-C-80*80*3; Nom: STAB; sets with these values: 2
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 43.7 m2; Hauteur: 80 mm; Largeur: 80 mm; sets with these values: 2
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000901 m2
Name | Repère de pièce = Repère d'assemblage = Reference | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
STAB | ST13 | 49.7 | 2.2 | 7027.5 | 7027.46 | 2.17148 | 0.00649337 | 0.00633174 | 50.973 | 49.7042
4 x STAB | ST12 | 42.6 | 1.9 | 6029.8 | 6029.8 | 1.86321 | 0.00557154 | 0.00543285 | 43.7366 | 42.6479
